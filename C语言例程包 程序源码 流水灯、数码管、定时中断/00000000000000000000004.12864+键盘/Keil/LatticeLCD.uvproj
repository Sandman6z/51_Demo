# Keil uVision project LatticeLCD.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: LatticeLCD +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include
  group Source Group 1
    ./sources/: main.c LCD12864.c KeyScan.c KeyProcess.c LCDShoeMap.c GameGraph.c
