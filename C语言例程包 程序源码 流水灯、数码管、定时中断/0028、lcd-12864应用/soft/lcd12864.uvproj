# Keil uVision project lcd12864.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(24000000)
  output: lcd12864 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    G:/民院/教学/课程/单片机原理与应用/课件/2009-创/sample/lcd-12864/soft/: STARTUP.A51
    ./: main.c
