# Keil uVision project 闪烁led.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(33000000) MODAT2
  output: 闪烁led +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 不同频率闪烁1个led灯.c
