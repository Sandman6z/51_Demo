# Keil uVision project huxideng.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: huxideng +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    C:/Users/Administrator/Desktop/51练习/呼吸灯/: STARTUP.A51
    ./: huxideng.c
