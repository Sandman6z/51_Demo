# Keil uVision project TEST522.uvproj, settings and files
target 射频读写卡器 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(33000000) MODAT2
  output: TEST522 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\51读写卡程序
  group 主程序
    ./: MAIN.C RC522.C
