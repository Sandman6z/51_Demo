# Keil uVision project LCD12864.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000) MODA2
  output: LCD12864 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: lcd12864.c
